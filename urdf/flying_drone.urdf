Commit message: fix: hybrid obstacle avoidance logic and collision physics

File: urdf/flying_drone.urdf (robot description, URDF)
Before this commit: robot quadcopter, 9 links, 8 joints
Links:
- link base_link: geometry collision box size=0.45 0.45 0.1; visual box size=0.15 0.15 0.05
